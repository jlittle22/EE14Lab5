# Keil uVision project project.Target_1.uvprojx, settings and files
target Target_1 (ARM-ADS)
  device: STM32L476VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __EVAL
  c include: c:/Keil_v5/ARM/PACK/Keil/STM32L4xx_DFP/2.6.1/Device/Include;
  asm define: __EVAL
  asm include: :/Keil_v5/ARM/PACK/Keil/STM32L4xx_DFP/2.6.1/Device/Include;
  memory RVCT4: RAM 0x8000000 size 0x100000
  memory RVCT9: ROM 0x20000000 size 0x18000
  memory RVCT10: ROM 0x10000000 size 0x8000
  scatter file: ./project.Target 1.sct
  link misc: --branchpatch=sdcomp-29491-629360 --summary_stderr --info summarysizes --load_addr_map_info --entry=Reset_Handler
  group Source Group 1
    ./: main.c startup_stm32l476xx.s stm32l476xx.h LED.c SysTick.h SysTick.c LCD.c LCD.h UART.h UART.c
software components: CMSIS:CORE 5.5.0
